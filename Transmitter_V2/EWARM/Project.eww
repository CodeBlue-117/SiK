<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CAB_BOX_PCB_CODE_V2.ewp</path>
  </project>
  <batchBuild />
</workspace>
